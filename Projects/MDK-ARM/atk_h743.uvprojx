# Keil uVision project atk_h743.uvprojx, settings and files
target LTDC LCD (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h743 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx LV_LVGL_H_INCLUDE_SIMPLE
  c misc: --diag_suppress=68 --diag_suppress=546 --diag_suppress=111 --diag_suppress=191
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\Middlewares\Freertos\include;..\..\Middlewares\Freertos\portable\RVDS\ARM_CM7\r0p1;..\..\Middlewares\MALLOC;..\..\Middlewares\LVGL\GUI\lvgl;..\..\Middlewares\LVGL\GUI\lvgl\src\core;..\..\Middlewares\LVGL\GUI\lvgl\src\display;..\..\Middlewares\LVGL\GUI\lvgl\src\draw;..\..\Middlewares\LVGL\GUI\lvgl\src\draw\dma2d;..\..\Middlewares\LVGL\GUI\lvgl\src\draw\sw;..\..\Middlewares\LVGL\GUI\lvgl\src\font;..\..\Middlewares\LVGL\GUI\lvgl\src\indev;..\..\Middlewares\LVGL\GUI\lvgl\src\layouts;..\..\Middlewares\LVGL\GUI\lvgl\src\layouts\flex;..\..\Middlewares\LVGL\GUI\lvgl\src\layouts\grid;..\..\Middlewares\LVGL\GUI\lvgl\src\libs;..\..\Middlewares\LVGL\GUI\lvgl\src\misc;..\..\Middlewares\LVGL\GUI\lvgl\src\misc\cache;..\..\Middlewares\LVGL\GUI\lvgl\src\misc\cache\class;..\..\Middlewares\LVGL\GUI\lvgl\src\misc\cache\instance;..\..\Middlewares\LVGL\GUI\lvgl\src\osal;..\..\Middlewares\LVGL\GUI\lvgl\src\themes;..\..\Middlewares\LVGL\GUI\lvgl\src\themes\default;..\..\Middlewares\LVGL\GUI\lvgl\src\stdlib;..\..\Middlewares\LVGL\GUI\lvgl\src\stdlib\builtin;..\..\Middlewares\LVGL\GUI\lvgl\src\stdlib\clib;..\..\Middlewares\LVGL\GUI\lvgl\src\tick;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\3dtexture;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\animimage;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\arc;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\arc;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\bar;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\button;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\buttonmatrix;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\calendar;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\canvas;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\chart;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\checkbox;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\dropdown;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\image;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\imagebutton;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\keyboard;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\label;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\led;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\line;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\list;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\lottie;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\menu;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\msgbox;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\objx_templ;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\property;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\roller;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\scale;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\slider;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\span;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\spinbox;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\spinner;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\switch;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\table;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\tabview;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\textarea;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\tileview;..\..\Middlewares\LVGL\GUI\lvgl\src\widgets\win;..\..\Middlewares\LVGL\GUI\lvgl\examples\porting;..\..\Middlewares\LVGL\GUI_APP\demos;..\..\Middlewares\LVGL\GUI_APP\demos\stress;..\..\Middlewares\FATFS\source
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c FreeRTOSConfig.h
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../Middlewares/LVGL/GUI/lvgl/: lv_conf.h lvgl.h
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_nand.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c ltdc.c
    ../../Drivers/BSP/SDRAM/: sdram.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/NAND/: ftl.c nand.c nandtester.c
  group Middlewares/FreeRTOS_Core
    ../../Middlewares/Freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_Port
    ../../Middlewares/Freertos/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../Middlewares/Freertos/portable/MemMang/: heap_4.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/lvgl/examples/porting
    ../../Middlewares/LVGL/GUI/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c lv_port_fs.c
  group Middlewares/lvgl/src
    ../../Middlewares/LVGL/GUI/lvgl/src/: lv_init.c
  group Middlewares/lvgl/src/core
    ../../Middlewares/LVGL/GUI/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group Middlewares/lvgl/src/display
    ../../Middlewares/LVGL/GUI/lvgl/src/display/: lv_display.c
  group Middlewares/lvgl/src/draw
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../Middlewares/LVGL/GUI/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group Middlewares/lvgl/src/font
    ../../Middlewares/LVGL/GUI/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/indev
    ../../Middlewares/LVGL/GUI/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group Middlewares/lvgl/src/layouts
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/: lv_layout.c
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c
    ../../Middlewares/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c
  group Middlewares/lvgl/src/libs
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/bmp/: lv_bmp.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/freetype/: lv_freetype.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/gif/: lv_gif.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/libpng/: lv_libpng.c
    ../../Middlewares/LVGL/GUI/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group Middlewares/lvgl/src/misc
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../../Middlewares/LVGL/GUI/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group Middlewares/lvgl/src/osal
    ../../Middlewares/LVGL/GUI/lvgl/src/osal/: lv_freertos.c lv_os.c
  group Middlewares/lvgl/src/stdlib
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/: lv_mem.c
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../Middlewares/LVGL/GUI/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group Middlewares/lvgl/src/themes
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/: lv_theme.c
    ../../Middlewares/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c
  group Middlewares/lvgl/src/tick
    ../../Middlewares/LVGL/GUI/lvgl/src/tick/: lv_tick.c
  group Middlewares/lvgl/src/widgets
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/button/: lv_button.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/image/: lv_image.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/scale/: lv_scale.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../Middlewares/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
  group Middlewares/lvgldemo/UI
    ../../Middlewares/LVGL/GUI_APP/demos/: lv_demos.c
    ../../Middlewares/LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
  group Middlewares/FATFS/source
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
